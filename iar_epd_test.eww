<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\iar_epd_test.ewp</path>
    </project>
    <batchBuild />
</workspace>
